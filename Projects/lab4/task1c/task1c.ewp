# IAR project task1c.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: task1c.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup_M.c Lab4_Inits.c Lab4_Inits.h Lab4_Task1b.h Lab4_Task1c.c Lab4_Task1c.h PLL_Header.h SSD2119_Display.c SSD2119_Display.h SSD2119_Touch.c SSD2119_Touch.h tm4c1294ncpdt.h
